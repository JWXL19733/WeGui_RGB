# Keil uVision project Project.uvprojx, settings and files
target WeGui_RGB (6230000::V6.23::ARMCLANG)
  device: CW32L012C8 WHXY
  pack: WHXY.CW32L012_DFP.1.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\cw32l012_peripheral\inc;..\..\CW32L012;..\Lcd_Port;..\..\Lcd_Driver;..\..\Lcd_WeGui
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\Project.sct
  group CMSIS
    ../cw32l012_peripheral/: startup_cw32l012.s
    ../cw32l012_peripheral/src/: system_cw32l012.c
  group cw32l012_peripheral
    ../cw32l012_peripheral/src/: cw32l012_adc.c cw32l012_atim.c cw32l012_btim.c cw32l012_cordic.c cw32l012_crc.c cw32l012_dac.c cw32l012_debug.c cw32l012_digitalsign.c cw32l012_dma.c cw32l012_eau.c cw32l012_flash.c cw32l012_gpio.c cw32l012_gtim.c cw32l012_halltim.c cw32l012_irmod.c cw32l012_iwdt.c cw32l012_lpi2c.c cw32l012_lptim.c cw32l012_lvd.c cw32l012_opa.c cw32l012_pwr.c cw32l012_ram.c cw32l012_rtc.c cw32l012_spi.c cw32l012_sysctrl.c cw32l012_systick.c cw32l012_uart.c cw32l012_vc.c cw32l012_wwdt.c
  group App
    ../: main.c interrupts_cw32l012.c
  group Lcd_Port
    ../Lcd_Port/: lcd_driver_config.h lcd_wegui_config.h cw32l012_lcd_soft_4spi_port.c cw32l012_lcd_hard_4spi_port.c cw32l012_lcd_soft_3spi_port.c cw32l012_lcd_hard_3spi_port.c cw32l012_lcd_soft_i2c_port.c cw32l012_lcd_hard_i2c_port.c cw32l012_wegui_6key_port.c cw32l012_wegui_4key_port.c
  group Lcd_Driver
    ../../Lcd_Driver/: lcd_driver.h lcd_driver.c lcd_res.h lcd_res.c gc9a01.c sh1106.c sh1107.c sh1108.c sh1115.c ssd1306.c ssd1309.c ssd1312.c ssd1315.c ssd1327.c st7735.c st7789v3.c st7789vw.c st7796s.c
  group Lcd_WeGui
    ../../Lcd_WeGui/: user_wegui_menu.c lcd_wegui_driver.c lcd_wegui_menu_app.c lcd_wegui_menu_mlist.c lcd_wegui_tip.c
software components: CMSIS:CORE 6.1.1
