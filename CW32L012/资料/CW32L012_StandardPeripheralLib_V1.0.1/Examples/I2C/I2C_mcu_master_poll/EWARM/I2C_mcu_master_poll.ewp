# IAR project I2C_mcu_master_poll.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32L012x8 WHXY CW32L012x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_mcu_master_poll.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: HC32F030.icf
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32l012_adc.c cw32l012_atim.c cw32l012_btim.c cw32l012_crc.c cw32l012_debug.c cw32l012_digitalsign.c cw32l012_dma.c cw32l012_eau.c cw32l012_flash.c cw32l012_gpio.c cw32l012_gtim.c cw32l012_iwdt.c cw32l012_lpi2c.c cw32l012_lvd.c cw32l012_opa.c cw32l012_pwr.c cw32l012_ram.c cw32l012_rtc.c cw32l012_spi.c cw32l012_sysctrl.c cw32l012_systick.c cw32l012_uart.c cw32l012_vc.c
  group Startup
    ../../../../IDEsupport/EWARM/: startup_cw32l012.s
    ../../../../Libraries/src/: system_cw32l012.c
  group User
    ../USER/src/: interrupts_cw32l012.c main.c
