# Keil uVision project I2C_mcu_slave_poll.uvprojx, settings and files
target I2C_mcu_slave_poll (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32L012C8 WHXY
  pack: WHXY.CW32L012_DFP.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_mcu_slave_poll +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l012.s
    ../../../../Libraries/src/: system_cw32l012.c
  group User
    ../USER/src/: main.c interrupts_cw32l012.c
  group Driver
    ../../../../Libraries/src/: cw32l012_lpi2c.c cw32l012_sysctrl.c cw32l012_gpio.c cw32l012_flash.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
