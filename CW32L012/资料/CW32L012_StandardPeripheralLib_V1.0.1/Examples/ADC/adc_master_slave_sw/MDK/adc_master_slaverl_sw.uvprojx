# Keil uVision project adc_master_slaverl_sw.uvprojx, settings and files
target adc_master_slave_sw (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32L012C8 WHXY
  pack: WHXY.CW32L012_DFP.0.0.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adc_master_slave_sw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: ..\..\..\..\IDEsupport\MDK;..\..\..\..\Libraries\inc;..\..\..\..\StartKit_Board;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l012.s
    ../../../../Libraries/src/: system_cw32l012.c
  group User
    ../USER/src/: main.c interrupts_cw32l012.c
  group Driver
    ../../../../Libraries/src/: cw32l012_adc.c cw32l012_sysctrl.c cw32l012_systick.c cw32l012_gpio.c cw32l012_uart.c
  group Doc
    ../: readme.txt
  group Bsp
    ../../../../StartKit_Board/: cw32l012_startkit.c
software components: CMSIS:CORE 5.1.2
