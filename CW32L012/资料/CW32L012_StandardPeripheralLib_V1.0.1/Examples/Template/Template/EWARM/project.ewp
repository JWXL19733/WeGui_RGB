# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CW32L012x8 WHXY CW32L012x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\inc; ..\..\..\..\StartKit_Board; ..\USER\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32l012.s
    ../../../../Libraries/src/: system_cw32l012.c
  group User
    ../USER/src/: main.c interrupts_cw32l012.c
  group Driver
    ../../../../Libraries/src/: cw32l012_sysctrl.c cw32l012_systick.c cw32l012_gpio.c cw32l012_uart.c cw32l012_flash.c
  group Doc
    ../: readme.txt
  group bsp
    ../../../../StartKit_Board/: cw32l012_startkit.c
  group Bsp
    ../../../../StartKit_Board/: cw32l012_startkit.c
