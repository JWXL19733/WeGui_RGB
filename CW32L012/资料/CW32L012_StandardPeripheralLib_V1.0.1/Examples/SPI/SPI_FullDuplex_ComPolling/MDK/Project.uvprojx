# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: CW32L012C8 WHXY
  pack: WHXY.CW32L012_DFP.1.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\IDEsupport\MDK;..\..\..\..\Libraries\inc;..\..\..\..\StartKit_Board;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../../../IDEsupport/MDK/: startup_cw32l012.s
    ../../../../Libraries/src/: system_cw32l012.c
  group User
    ../USER/src/: main.c
  group Driver
    ../../../../Libraries/src/: cw32l012_gpio.c cw32l012_spi.c cw32l012_sysctrl.c cw32l012_systick.c
  group Doc
    ../: readme.txt
  group Bsp
    ../../../../StartKit_Board/: cw32l012_startkit.c
software components: CMSIS:CORE 6.1.1
