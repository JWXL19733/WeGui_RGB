# Keil uVision project Project.uvprojx, settings and files
target WeGui_RGB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Lcd_Port;..\..\Lcd_Driver;..\..\Lcd_WeGui;..\..\STM32F103;..\MDK-ARM;..\..\Lcd_Demo;..\..\Misc\ATK_RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_usart.c
  group User
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group Lcd_Port
    ../Lcd_Port/: lcd_driver_config.h lcd_wegui_config.h stm32f103_lcd_dma_4spi_port.c stm32f103_lcd_hard_4spi_port.c stm32f103_lcd_hard_iic_port.c stm32f103_lcd_soft_3spi_port.c stm32f103_lcd_soft_4spi_port.c stm32f103_lcd_soft_iic_port.c stm32f103_wegui_4key_port.c stm32f103_wegui_ec_port.c stm32f103_wegui_uart_port.c stm32f103_flash_soft_stdspi_port.c stm32f103_flash_hard_stdspi_port.c stm32f103_flash_dma_stdspi_port.c
  group Lcd_Driver
    ../../Lcd_Driver/: lcd_driver.h lcd_driver.c lcd_res.h lcd_res.c flash_driver.c w25qxx.c sh1106.c sh1107.c sh1108.c sh1115.c ssd1306.c ssd1309.c ssd1312.c ssd1315.c ssd1327.c st7735.c st7789v3.c st7789vw.c st7796s.c gc9a01.c
  group Lcd_WeGui
    ../../Lcd_WeGui/: lcd_wegui_driver.c lcd_wegui_tip.c lcd_wegui_menu_mlist.c lcd_wegui_menu_mlist2.c
  group Lcd_Demo
    ../../Lcd_Demo/: driver_demo.c wegui_menu_demo.h wegui_menu_demo.c flash_img_demo.h
